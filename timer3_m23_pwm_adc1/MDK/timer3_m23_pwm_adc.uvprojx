# Keil uVision project timer3_m23_pwm_adc.uvprojx, settings and files
target timer3_m23_pwm_adc_Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F030K8TA HDSC
  pack: HDSC.HC32F030.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: timer3_m23_pwm_adc +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f030.s
    ../../../../mcu/common/: system_hc32f030.c
  group source
    ../source/: main.c
  group driver
    ../../../../driver/src/: ddl.c interrupts_hc32f030.c sysctrl.c timer3.c lpm.c gpio.c flash.c adc.c uart.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 5.1.1
